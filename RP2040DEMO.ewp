# IAR project RP2040DEMO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RP2040DEMO.srec
  ILINK.IlinkOutputFile: ext.out
  ILINK.IlinkKeepSymbols: __vector_table
  ILINK.IlinkIcfFile: RP2040.icf
  ILINK.IlinkProgramEntryLabel: main
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c startup_rp2040.c
